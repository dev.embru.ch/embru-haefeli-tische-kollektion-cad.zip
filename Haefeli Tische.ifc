Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.1]
File name: Haefeli Tische.ifc
Time: 2022-02-15T11:39:46
Written by: pCon.planner

# IfcBuilding
ElevationOfRefHeight: 0 m; ElevationOfTerrain: 0 m

# IfcBuildingStorey
Elevation: 0 m

# IfcFurniture (15)
Pset_ManufacturerTypeInformation - Manufacturer: Embru Klassiker
Name | Description | ArticleNumber
Gartentisch-Lounge Ø 60cm Mod. 1112 Haefeli H.40cm | Gartentisch-Lounge Ø 60cm Mod. 1112 Haefeli H.40cm Modell 1112 Tischplatte nicht klappbar Max Ernst Haefeli, Werksentwurf 2012 | 1020130
Gartentisch-Lounge Ø 80cm Modell 1102 Haefeli H.40cm | Gartentisch-Lounge Ø 80cm Modell 1102 Haefeli H.40cm Modell 1102 Tischplatte nicht klappbar Max Ernst Haefeli, Werksentwurf 2012 | 1020131
Gartentisch Haefeli Ø 60cm Modell 1132 rund H.74cm | Gartentisch Haefeli Ø 60cm Modell 1132 rund H.74cm Modell 1132 Tischplatte klappbar mit Arretierungshebel Max Ernst Haefeli, Entwurf 1939 | 1020143
Gartentisch Haefeli Ø 70cm Modell 1127 rund H.74cm | Gartentisch Haefeli Ø 70cm Modell 1127 rund H.74cm Modell 1127 Tischplatte klappbar mit Arretierungshebel Max Ernst Haefeli, Werksentwurf 2018 | 1020148
Gartentisch Haefeli Ø 80cm Modell 1106 rund H.74cm | Gartentisch Haefeli Ø 80cm Modell 1106 rund H.74cm Modell 1106 Tischplatte klappbar mit Arretierungshebel Max Ernst Haefeli, Entwurf 1939 | 1020132
Gartentisch Haefeli Ø 90cm Modell 1135 rund H.74cm | Gartentisch Haefeli Ø 90cm Modell 1135 rund H.74cm Modell 1135 Tischplatte klappbar mit Arretierungshebel Max Ernst Haefeli, Entwurf 1939 | 1020146
Gartentisch Haefeli 65x65cm Mod. 1133 quadrat H.74cm | Gartentisch Haefeli 65x65cm Mod. 1133 quadrat H.74cm Modell 1133 Tischplatte klappbar mit Arretierungshebel Max Ernst Haefeli, Entwurf 1939 | 1020144
Gartentisch Haefeli 80x80cm Mod. 1115 quadrat H.74cm | Gartentisch Haefeli 80x80cm Mod. 1115 quadrat H.74cm Modell 1115 Tischplatte klappbar mit Arretierungshebel Max Ernst Haefeli, Entwurf 1939 | 1020133
Gartentisch Haefeli 120cm Mod.1134 rechteck H.74cm | Gartentisch Haefeli 120cm Mod.1134 rechteck H.74cm Modell 1134 Tischplatte klappbar mit Arretierungshebel Max Ernst Haefeli, Entwurf 1939 | 1020145
Gartentisch Haefeli 140cm Mod.1122 rechteck H.74cm | Gartentisch Haefeli 140cm Mod.1122 rechteck H.74cm Modell 1122 Tischplatte klappbar mit Arretierungshebel Max Ernst Haefeli, Entwurf 1939 | 1020138
Gartentisch Haefeli 160cm Mod.1104 rechteck H.74cm | Gartentisch Haefeli 160cm Mod.1104 rechteck H.74cm Modell 1104 Tischplatte klappbar mit Arretierungshebel Max Ernst Haefeli, Entwurf 1939 | 1020134
Gartentisch Haefeli 180cm Mod.1109 rechteck H.74cm | Gartentisch Haefeli 180cm Mod.1109 rechteck H.74cm Modell 1109 Tischplatte klappbar mit Arretierungshebel Max Ernst Haefeli, Entwurf 1939 | 1020135
Gartentisch Haefeli 240cm Mod.1131 rechteck H.74cm | Gartentisch Haefeli 240cm Mod.1131 rechteck H.74cm Modell 1131 Tischplatte klappbar mit Arretierungshebel Max Ernst Haefeli, Entwurf 1939 | 1020140
Gartenstehtisch Haefeli Modell 1118 rund H.105cm | Gartenstehtisch Haefeli Modell 1118 rund H.105cm Modell 1118 Tischplatte klappbar mit Arretierungshebel Max Ernst Haefeli, Werksentwurf 2011 | 1020136
Gartenstehtisch Haefeli Mod.1119 quadrat H.105cm | Gartenstehtisch Haefeli Mod.1119 quadrat H.105cm Modell 1119 Tischplatte klappbar mit Arretierungshebel Max Ernst Haefeli, Werksentwurf 2011 | 1020137
